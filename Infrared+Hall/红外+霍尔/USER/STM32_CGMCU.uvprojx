# Keil uVision project STM32_CGMCU.uvprojx, settings and files
target DHT11 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_CGMCU
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\HARDWARE\DHT11;..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\OLED;..\HARDWARE\GM_ADC;..\SYSTEM\adc;..\HARDWARE\HC-SR501;..\HARDWARE\Serial;..\NET;..\HARDWARE\ESP8266;..\HARDWARE\Environment;..\HARDWARE\Time;..\HARDWARE\Usart;..\HARDWARE\Beef;..\HARDWARE\DHT11;..\HARDWARE\HALL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/HC-SR501/: body_hw.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/Environment/: AD.c
    ../HARDWARE/Time/: time.c
    ../HARDWARE/Usart/: usart.c
    ../HARDWARE/Beef/: Beef.c
    ../HARDWARE/DHT11/: DHT11.c
    ../HARDWARE/HALL/: GUA_ Hall_Sensor.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/adc/: adcx.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c
